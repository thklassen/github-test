# Keil uVision project Blinky.uvprojx, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c misc: --cs-on
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --cs-on
  group Source Files
    ./: Blinky.c Retarget.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32E/Common/: ADC.c GLCD_16bitIF_STM32F10x.c LED.c
  group ::Device
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: GPIO_STM32F10x.c
target STM32F103 RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target STM32F103 Flash (SIM) (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c misc: --cs-on
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --cs-on
software components: CMSIS:CORE 3.20.0, Board Support:MCBSTM32E:A/D Converter 1.0.0, Board Support:MCBSTM32E:Graphic LCD 1.0.0, Board Support:MCBSTM32E:LED 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0
